# Keil uVision project project.uvprojx, settings and files
target v1.0 (ARM-ADS)
  device: STM32F429ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,USE_USB_OTG_FS
  c misc: --locale=english
  c include: ..\..\lib\arm\usb\STM32_USB_Device_Library\Class\msc\inc;..\..\lib\arm\usb\STM32_USB_Device_Library\Core\inc;..\..\lib\arm\usb\STM32_USB_OTG_Driver\inc;..\..\app;..\..\bsp\inc;..\..\gui\inc;..\..\module\inc;..\..\os\systask\inc;..\..\os\include;..\..\os\portable\RVDS\ARM_CM4F;..\..\fs;..\..\emWin\uiBuild\ingredients\inc;..\..\emWin\uiBuild\core\inc;..\..\emWin\core\config;..\..\emWin\core\inc;..\..\emWin\icon;..\..\lib\arm\core;..\..\lib\arm\lib\inc;..\..\app\normal\inc;..\..\mqtt\samples;..\..\mqtt\src;..\..\mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\project.sct
  group app
    ../../app/normal/src/: main.c app_localdb.c app_scanner.c app_voice.c app_wifi_common.c app_wifista.c app_exp_routine.c app_http.c app_epoch_match.c app_mqtt.c
    ../../app/normal/inc/: ep_app.h
  group bsp
    ../../bsp/src/: bsp_systick.c bsp_uart.c bsp_timer.c bsp_lcd.c bsp_ctiic.c bsp_gt9147.c bsp_touch.c bsp_spi_flash.c bsp_stmflash.c bsp_exti.c bsp.c bsp_lp_rcc.c driver.c bsp_spi.c bsp_rc522.c
  group module
    ../../module/src/: error.c handler.c oop.c parse.c shell.c parson.c malloc.c
  group os\core
    ../../os/core/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os\portable
    ../../os/portable/MemMang/: heap_4.c
    ../../os/portable/RVDS/ARM_CM4F/: port.c
  group fs
    ../../fs/: diskio.c ff.c
    ../../fs/option/: cc936.c
  group emwin\uiBuild\ingredients
    ../../emWin/uiBuild/ingredients/src/: UI_Font.c UI_MainWindow.c UI_SubExpWindow.c UI_ConfirmWindow.c UI_Keyboard.c UI_SettingWindow.c UI_NotifyWindow.c UI_FullKeyboard.c UI_FullKeyboardPage.c UI_SkinButton.c UI_ConnectWindow.c UI_SkinSlider.c
  group emwin\uiBuild\core
    ../../emWin/uiBuild/core/src/: UI_Touch.c UI_MainTask.c UI_Logic.c UI_Effect.c
    ../../emWin/uiBuild/ingredients/src/: UI_pushButton.c
  group emwin\icon
    ../../emWin/icon/src/: buttom_bar.c hdu_logo.c hdu_pic.c rect_bar.c rect_sublist.c right_side_bar.c question.c submit.c exp_start.c logout.c finish.c unfinished.c waiting.c key1_up.c key2_up.c key1_down.c key2_down.c switch_on.c switch_off.c unikeyUp.c unikeyDown.c keyType2Down.c keyType2Up.c wifi.c wifi_off.c sliderThumb.c
  group emwin\config
    ../../emWin/core/config/: GUI_X_Touch.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.c GUI_X_OS.c
  group emwin\lib
    ../../emWin/core/lib/ARM/: GUI_CM4F_L.lib
  group arm\core
    ../../lib/arm/core/: startup_stm32f429xx.s
  group arm\dsp
    ../../lib/arm/dsp/lib/: arm_cortexM4lf_math.lib
  group arm\lib
    ../../lib/arm/lib/src/: system_stm32f4xx.c misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_fmc.c stm32f4xx_it.c
