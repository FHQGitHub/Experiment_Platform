# Keil uVision project OS&EMWIN.uvprojx, settings and files
target OS&EMWIN (ARM-ADS)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: OS&EMWIN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM,OS_SUPPORT,GUI_SUPPORT_TOUCH
  c include: ..\..\ME-USR;..\..\ME-PER\Inner;..\..\ME-PER\Outer;..\..\..\OS\uC-BSP;..\..\..\OS\uC-CFG;..\..\..\OS\uC-CPU;..\..\..\OS\uC-LIB;..\..\..\OS\uCOS-III\Ports;..\..\..\OS\uCOS-III\Source;..\..\..\ST\ST-DSP\inc;..\..\..\ST\ST-CORE;..\..\..\ST\ST-LIB\inc;..\..\..\EW\EW-ME;..\..\..\EW\EW-CFG;..\..\..\EW\EW-DEMO;..\..\..\EW\EW-LIB\inc;..\..\..\FF\FF-SRC;..\..\..\FF\FF-EXFUNS;..\..\ME-PER;..\..\ME-PER\Outer;..\..\ME-PER\Inner;..\..\ME-PER\Inner;..\..\ME-PER\Outer;..\..\..\EW\EW-ICON
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ME-USR
    ../../ME-USR/: delay.c main.c malloc.c redirprintf.c
    ../../ME-PER/Inner/: usart2.c uart.c
  group ME-PER
    ../../ME-PER/Inner/: timer.c time7.c
    ../../ME-PER/Outer/: stmflash.c bsp_spi_flash.c SPI.c
  group ST-CORE
    ../../../ST/ST-CORE/: startup_stm32f429xx.s
  group ST-DSP
    ../../../ST/ST-DSP/lib/: arm_cortexM4lf_math.lib
  group ST-LIB
    ../../../ST/ST-LIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c
